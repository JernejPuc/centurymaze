Commit message: Update colours, image preprocessing and encoder pretraining

File: src/mazebots/assets/mazebot.urdf (robot description, URDF)
Before this commit: robot tbot, 12 links, 11 joints
Links:
- link sensor: geometry visual box size=0.02 0.09 0.06
